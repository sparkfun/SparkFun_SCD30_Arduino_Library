# Keil uVision project SCD30_SampleCode.uvprojx, settings and files
target STM32-Discovery (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STS3x_SampleCode +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD_VL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./Source/: startup_stm32f10x_md_vl.s
  group Source Files
    ./Source/: i2c_hal.c main.c system.c SCD30.c
software components: CMSIS:CORE 4.3.0
